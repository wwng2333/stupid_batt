# Keil uVision project STC8G-AXP173.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: AXP173 +hex
  group Source Group 1
    ./src/: STARTUP.A51 main.c main.h UART.c UART.h I2C.c I2C.h Delay.c Delay.h
